Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\SOLIDWORKS WORKING\00-KINLEY\SUBS\IFC\KI-0001-U07.IFC
Time: 2026-05-01T10:16:07+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
SOLIDWORKS Custom Properties - Author: J.S; GA: No; Number: U - 01 - 300~600; OriginationDate: 28/07/2025; Project Name: Design Projects; RevCreatedBy: J.S; RevCreationDate: 28/07/2025; Revision: M01; TAC NUMBER: C05+C05; WEIGHT: 38.46
PSet_Mass_Property - Area Measure: 3.3268296297017774; Mass Measure: 38.4642758184538351; Volume Measure: 0.0049313174126223

# IfcBuilding, default Building
SOLIDWORKS Custom Properties - Author: J.S; GA: No; Number: U - 01 - 300~600; OriginationDate: 28/07/2025; Project Name: Design Projects; RevCreatedBy: J.S; RevCreationDate: 28/07/2025; Revision: M01; TAC NUMBER: C05+C05; WEIGHT: 38.46
PSet_Mass_Property - Area Measure: 3.3268296297017774; Mass Measure: 38.4642758184538351; Volume Measure: 0.0049313174126223

# IfcBuildingStorey, default BuildingStorey
In: default Building
SOLIDWORKS Custom Properties - Author: J.S; GA: No; Number: U - 01 - 300~600; OriginationDate: 28/07/2025; Project Name: Design Projects; RevCreatedBy: J.S; RevCreationDate: 28/07/2025; Revision: M01; TAC NUMBER: C05+C05; WEIGHT: 38.46
PSet_Mass_Property - Area Measure: 3.3268296297017774; Mass Measure: 38.4642758184538351; Volume Measure: 0.0049313174126223

# IfcBuildingElementProxy: AECARCHITECTURALELEMENT (5)
In: default BuildingStorey
SOLIDWORKS Custom Properties - Finish: Unchecked
Name | Author = RevCreatedBy | DESCRIPTION | GA | Number | OriginationDate = RevCreationDate | Project Name | Revision | WEIGHT
KI-0000-GS01 | J.S | KI-0000-GS01 | No | S-GS01 - 300 - 600 | 28/07/2025 | Design Projects | M01 | 0.90
KI-0000-GS01-1 | J.S | KI-0000-GS01 | No | S-GS01 - 300 - 600 | 28/07/2025 | Design Projects | M01 | 0.90
SHEET^KI-0001-U07 |  | SHEET^KI-0001-U07 |  |  |  |  |  | 34.85
KI-0000-GS01-2 | J.S | KI-0000-GS01 | No | S-GS01 - 300 - 600 | 28/07/2025 | Design Projects | M01 | 0.90
KI-0000-GS01-3 | J.S | KI-0000-GS01 | No | S-GS01 - 300 - 600 | 28/07/2025 | Design Projects | M01 | 0.90

# IfcElementAssembly, KI-0001-U07
In: default BuildingStorey
SOLIDWORKS Custom Properties - Author: J.S; GA: No; Number: U - 01 - 300~600; OriginationDate: 28/07/2025; Project Name: Design Projects; RevCreatedBy: J.S; RevCreationDate: 28/07/2025; Revision: M01; TAC NUMBER: C05+C05; WEIGHT: 38.46
PSet_Mass_Property - Area Measure: 3.3268296297017774; Mass Measure: 38.4642758184538351; Volume Measure: 0.0049313174126223
