Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\SOLIDWORKS WORKING\00-KINLEY\SUBS\KI-0001-BU02.IFC
Time: 2026-05-01T10:23:38+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
SOLIDWORKS Custom Properties - Author: J.S; GA: No; Number: U - 01 - 300~600; OriginationDate: 28/07/2025; Project Name: Design Projects; RevCreatedBy: J.S; RevCreationDate: 28/07/2025; Revision: M01; TAC NUMBER: C05+C05; WEIGHT: 62.51
PSet_Mass_Property - Area Measure: 5.4259706797991045; Mass Measure: 62.5062517240543087; Volume Measure: 0.0671328220159044

# IfcBuilding, default Building
SOLIDWORKS Custom Properties - Author: J.S; GA: No; Number: U - 01 - 300~600; OriginationDate: 28/07/2025; Project Name: Design Projects; RevCreatedBy: J.S; RevCreationDate: 28/07/2025; Revision: M01; TAC NUMBER: C05+C05; WEIGHT: 62.51
PSet_Mass_Property - Area Measure: 5.4259706797991045; Mass Measure: 62.5062517240543087; Volume Measure: 0.0671328220159044

# IfcBuildingStorey, default BuildingStorey
In: default Building
SOLIDWORKS Custom Properties - Author: J.S; GA: No; Number: U - 01 - 300~600; OriginationDate: 28/07/2025; Project Name: Design Projects; RevCreatedBy: J.S; RevCreationDate: 28/07/2025; Revision: M01; TAC NUMBER: C05+C05; WEIGHT: 62.51
PSet_Mass_Property - Area Measure: 5.4259706797991045; Mass Measure: 62.5062517240543087; Volume Measure: 0.0671328220159044

# IfcBuildingElementProxy: AECARCHITECTURALELEMENT (7)
In: default BuildingStorey
SOLIDWORKS Custom Properties - Finish: Unchecked
Name | DESCRIPTION | WEIGHT | Material
SHEET^KI-0001-BU02 | SHEET^KI-0001-BU02 | 17.10
KI-0000-GS01 | KI-0000-GS01 | 0.90 | SOLIDWORKS Custom Properties - Author: J.S; GA: No; Number: S-GS01 - 300 - 600; OriginationDate: 28/07/2025; Project Name: Design Projects; RevCreatedBy: J.S; RevCreationDate: 28/07/2025; Revision: M01
KI-0000-GS01-1 | KI-0000-GS01 | 0.90 | SOLIDWORKS Custom Properties - Author: J.S; GA: No; Number: S-GS01 - 300 - 600; OriginationDate: 28/07/2025; Project Name: Design Projects; RevCreatedBy: J.S; RevCreationDate: 28/07/2025; Revision: M01
KI-0000-RAVA BENCH ATTACHMENT | KI-0000-RAVA BENCH ATTACHMENT | 0.49 | MILD STEEL
RAVA BENCH | RAVA BENCH | 21.31 | IROKO
RAVA BENCH-1 | RAVA BENCH | 21.31 | IROKO
KI-0000-RAVA BENCH ATTACHMENT-1 | KI-0000-RAVA BENCH ATTACHMENT | 0.49 | MILD STEEL

# IfcElementAssembly, KI-0001-BU02
In: default BuildingStorey
SOLIDWORKS Custom Properties - Author: J.S; GA: No; Number: U - 01 - 300~600; OriginationDate: 28/07/2025; Project Name: Design Projects; RevCreatedBy: J.S; RevCreationDate: 28/07/2025; Revision: M01; TAC NUMBER: C05+C05; WEIGHT: 62.51
PSet_Mass_Property - Area Measure: 5.4259706797991045; Mass Measure: 62.5062517240543087; Volume Measure: 0.0671328220159044
