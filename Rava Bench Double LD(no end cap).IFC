Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\SOLIDWORKS WORKING\00-KINLEY\SUBS\KI-0001-LD-BU02.IFC
Time: 2026-05-01T10:21:46+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
SOLIDWORKS Custom Properties - Author: J.S; GA: No; Number: U - 01 - 300~600; OriginationDate: 28/07/2025; Project Name: Design Projects; RevCreatedBy: J.S; RevCreationDate: 28/07/2025; Revision: M01; TAC NUMBER: C05+C05; WEIGHT: 63.66
PSet_Mass_Property - Area Measure: 5.5302934392849430; Mass Measure: 63.6554633577472444; Volume Measure: 0.0672801568407368

# IfcBuilding, default Building
SOLIDWORKS Custom Properties - Author: J.S; GA: No; Number: U - 01 - 300~600; OriginationDate: 28/07/2025; Project Name: Design Projects; RevCreatedBy: J.S; RevCreationDate: 28/07/2025; Revision: M01; TAC NUMBER: C05+C05; WEIGHT: 63.66
PSet_Mass_Property - Area Measure: 5.5302934392849430; Mass Measure: 63.6554633577472444; Volume Measure: 0.0672801568407368

# IfcBuildingStorey, default BuildingStorey
In: default Building
SOLIDWORKS Custom Properties - Author: J.S; GA: No; Number: U - 01 - 300~600; OriginationDate: 28/07/2025; Project Name: Design Projects; RevCreatedBy: J.S; RevCreationDate: 28/07/2025; Revision: M01; TAC NUMBER: C05+C05; WEIGHT: 63.66
PSet_Mass_Property - Area Measure: 5.5302934392849430; Mass Measure: 63.6554633577472444; Volume Measure: 0.0672801568407368

# IfcBuildingElementProxy: AECARCHITECTURALELEMENT (8)
In: default BuildingStorey
SOLIDWORKS Custom Properties - Finish: Unchecked
Name | DESCRIPTION | WEIGHT | Material
KI-0000-LD-GS01 | KI-0000-LD-GS01 | 1.05 | SOLIDWORKS Custom Properties - Author: J.S; GA: No; Number: L-GS01 - 300 - 600; OriginationDate: 06/08/2025; Project Name: Design Projects; RevCreatedBy: J.S; RevCreationDate: 06/08/2025; Revision: M01
SHEET^KI-0001-LD-BU02 | SHEET^KI-0001-LD-BU02 | 4.37
Part2^KI-0001-LD-BU02 | Part2^KI-0001-LD-BU02 | 13.59 | MILD STEEL
KI-0000-LD-GS01-1 | KI-0000-LD-GS01 | 1.05 | SOLIDWORKS Custom Properties - Author: J.S; GA: No; Number: L-GS01 - 300 - 600; OriginationDate: 06/08/2025; Project Name: Design Projects; RevCreatedBy: J.S; RevCreationDate: 06/08/2025; Revision: M01
KI-0000-RAVA BENCH ATTACHMENT | KI-0000-RAVA BENCH ATTACHMENT | 0.49 | MILD STEEL
KI-0000-RAVA BENCH ATTACHMENT-1 | KI-0000-RAVA BENCH ATTACHMENT | 0.49 | MILD STEEL
RAVA BENCH | RAVA BENCH | 21.31 | IROKO
RAVA BENCH-1 | RAVA BENCH | 21.31 | IROKO

# IfcElementAssembly, KI-0001-LD-BU02
In: default BuildingStorey
SOLIDWORKS Custom Properties - Author: J.S; GA: No; Number: U - 01 - 300~600; OriginationDate: 28/07/2025; Project Name: Design Projects; RevCreatedBy: J.S; RevCreationDate: 28/07/2025; Revision: M01; TAC NUMBER: C05+C05; WEIGHT: 63.66
PSet_Mass_Property - Area Measure: 5.5302934392849430; Mass Measure: 63.6554633577472444; Volume Measure: 0.0672801568407368
