Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\SOLIDWORKS WORKING\00-KINLEY\SUBS\KI-0001-LD-BU01.IFC
Time: 2026-05-01T10:21:56+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
SOLIDWORKS Custom Properties - Author: J.S; GA: No; Number: U - 01 - 300~600; OriginationDate: 28/07/2025; Project Name: Design Projects; RevCreatedBy: J.S; RevCreationDate: 28/07/2025; Revision: M01; TAC NUMBER: C05+C05; WEIGHT: 41.86
PSet_Mass_Property - Area Measure: 3.6373277326650131; Mass Measure: 41.8566580925632366; Volume Measure: 0.0349258382169953

# IfcBuilding, default Building
SOLIDWORKS Custom Properties - Author: J.S; GA: No; Number: U - 01 - 300~600; OriginationDate: 28/07/2025; Project Name: Design Projects; RevCreatedBy: J.S; RevCreationDate: 28/07/2025; Revision: M01; TAC NUMBER: C05+C05; WEIGHT: 41.86
PSet_Mass_Property - Area Measure: 3.6373277326650131; Mass Measure: 41.8566580925632366; Volume Measure: 0.0349258382169953

# IfcBuildingStorey, default BuildingStorey
In: default Building
SOLIDWORKS Custom Properties - Author: J.S; GA: No; Number: U - 01 - 300~600; OriginationDate: 28/07/2025; Project Name: Design Projects; RevCreatedBy: J.S; RevCreationDate: 28/07/2025; Revision: M01; TAC NUMBER: C05+C05; WEIGHT: 41.86
PSet_Mass_Property - Area Measure: 3.6373277326650131; Mass Measure: 41.8566580925632366; Volume Measure: 0.0349258382169953

# IfcBuildingElementProxy: AECARCHITECTURALELEMENT (6)
In: default BuildingStorey
SOLIDWORKS Custom Properties - Finish: Unchecked
Name | DESCRIPTION | WEIGHT
SHEET^KI-0001-LD-BU01 | SHEET^KI-0001-LD-BU01 | 4.37
Part2^KI-0001-LD-BU01 | Part2^KI-0001-LD-BU01 | 13.59 | SOLIDWORKS Custom Properties - Material: MILD STEEL
KI-0000-LD-GS01 | KI-0000-LD-GS01 | 1.05 | SOLIDWORKS Custom Properties - Author: J.S; GA: No; Number: L-GS01 - 300 - 600; OriginationDate: 06/08/2025; Project Name: Design Projects; RevCreatedBy: J.S; RevCreationDate: 06/08/2025; Revision: M01
RAVA BENCH | RAVA BENCH | 21.31 | SOLIDWORKS Custom Properties - Material: IROKO
KI-0000-LD-GS01-1 | KI-0000-LD-GS01 | 1.05 | SOLIDWORKS Custom Properties - Author: J.S; GA: No; Number: L-GS01 - 300 - 600; OriginationDate: 06/08/2025; Project Name: Design Projects; RevCreatedBy: J.S; RevCreationDate: 06/08/2025; Revision: M01
KI-0000-RAVA BENCH ATTACHMENT | KI-0000-RAVA BENCH ATTACHMENT | 0.49 | SOLIDWORKS Custom Properties - Material: MILD STEEL

# IfcElementAssembly, KI-0001-LD-BU01
In: default BuildingStorey
SOLIDWORKS Custom Properties - Author: J.S; GA: No; Number: U - 01 - 300~600; OriginationDate: 28/07/2025; Project Name: Design Projects; RevCreatedBy: J.S; RevCreationDate: 28/07/2025; Revision: M01; TAC NUMBER: C05+C05; WEIGHT: 41.86
PSet_Mass_Property - Area Measure: 3.6373277326650131; Mass Measure: 41.8566580925632366; Volume Measure: 0.0349258382169953
