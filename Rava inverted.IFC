Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\SOLIDWORKS WORKING\00-KINLEY\SUBS\IFC\KI-0001-U08.IFC
Time: 2026-05-01T10:15:53+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
SOLIDWORKS Custom Properties - Author: J.S; GA: No; Number: U - 01 - 300~600; OriginationDate: 28/07/2025; Project Name: Design Projects; RevCreatedBy: J.S; RevCreationDate: 28/07/2025; Revision: M01; TAC NUMBER: C05+C05; WEIGHT: 20.00
PSet_Mass_Property - Area Measure: 1.7384255160603719; Mass Measure: 20.0046344315274673; Volume Measure: 0.0025646967219907

# IfcBuilding, default Building
SOLIDWORKS Custom Properties - Author: J.S; GA: No; Number: U - 01 - 300~600; OriginationDate: 28/07/2025; Project Name: Design Projects; RevCreatedBy: J.S; RevCreationDate: 28/07/2025; Revision: M01; TAC NUMBER: C05+C05; WEIGHT: 20.00
PSet_Mass_Property - Area Measure: 1.7384255160603719; Mass Measure: 20.0046344315274673; Volume Measure: 0.0025646967219907

# IfcBuildingStorey, default BuildingStorey
In: default Building
SOLIDWORKS Custom Properties - Author: J.S; GA: No; Number: U - 01 - 300~600; OriginationDate: 28/07/2025; Project Name: Design Projects; RevCreatedBy: J.S; RevCreationDate: 28/07/2025; Revision: M01; TAC NUMBER: C05+C05; WEIGHT: 20.00
PSet_Mass_Property - Area Measure: 1.7384255160603719; Mass Measure: 20.0046344315274673; Volume Measure: 0.0025646967219907

# IfcBuildingElementProxy: AECARCHITECTURALELEMENT (9)
In: default BuildingStorey
SOLIDWORKS Custom Properties - Finish: Unchecked
Name | DESCRIPTION | WEIGHT | Material
KI-0000-GS01 | KI-0000-GS01 | 0.90 | SOLIDWORKS Custom Properties - Author: J.S; GA: No; Number: S-GS01 - 300 - 600; OriginationDate: 28/07/2025; Project Name: Design Projects; RevCreatedBy: J.S; RevCreationDate: 28/07/2025; Revision: M01
Part6^KI-0001-U08 | Part6^KI-0001-U08 | 0.14 | MILD STEEL
Part5^KI-0001-U08 | Part5^KI-0001-U08 | 0.02 | MILD STEEL
SHEET^KI-0001-U08 | SHEET^KI-0001-U08 | 17.70
KI-0000-GS01-1 | KI-0000-GS01 | 0.90 | SOLIDWORKS Custom Properties - Author: J.S; GA: No; Number: S-GS01 - 300 - 600; OriginationDate: 28/07/2025; Project Name: Design Projects; RevCreatedBy: J.S; RevCreationDate: 28/07/2025; Revision: M01
Part5^KI-0001-U08-1 | Part5^KI-0001-U08 | 0.02 | MILD STEEL
Part5^KI-0001-U08-2 | Part5^KI-0001-U08 | 0.02 | MILD STEEL
Part6^KI-0001-U08-1 | Part6^KI-0001-U08 | 0.14 | MILD STEEL
Part6^KI-0001-U08-2 | Part6^KI-0001-U08 | 0.14 | MILD STEEL

# IfcElementAssembly, KI-0001-U08
In: default BuildingStorey
SOLIDWORKS Custom Properties - Author: J.S; GA: No; Number: U - 01 - 300~600; OriginationDate: 28/07/2025; Project Name: Design Projects; RevCreatedBy: J.S; RevCreationDate: 28/07/2025; Revision: M01; TAC NUMBER: C05+C05; WEIGHT: 20.00
PSet_Mass_Property - Area Measure: 1.7384255160603719; Mass Measure: 20.0046344315274673; Volume Measure: 0.0025646967219907
