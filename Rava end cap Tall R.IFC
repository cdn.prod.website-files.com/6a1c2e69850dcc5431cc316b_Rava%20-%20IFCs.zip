Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\SOLIDWORKS WORKING\00-KINLEY\SUBS\KI-0001-U01.IFC
Time: 2026-05-01T10:17:25+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
SOLIDWORKS Custom Properties - Author: J.S; GA: No; Number: U - 01 - 300~600; OriginationDate: 28/07/2025; Project Name: Design Projects; RevCreatedBy: J.S; RevCreationDate: 28/07/2025; Revision: M01; TAC NUMBER: C05+C05; WEIGHT: 18.92
PSet_Mass_Property - Area Measure: 1.6402905939715318; Mass Measure: 18.9159925204957062; Volume Measure: 0.0024251272462174

# IfcBuilding, default Building
SOLIDWORKS Custom Properties - Author: J.S; GA: No; Number: U - 01 - 300~600; OriginationDate: 28/07/2025; Project Name: Design Projects; RevCreatedBy: J.S; RevCreationDate: 28/07/2025; Revision: M01; TAC NUMBER: C05+C05; WEIGHT: 18.92
PSet_Mass_Property - Area Measure: 1.6402905939715318; Mass Measure: 18.9159925204957062; Volume Measure: 0.0024251272462174

# IfcBuildingStorey, default BuildingStorey
In: default Building
SOLIDWORKS Custom Properties - Author: J.S; GA: No; Number: U - 01 - 300~600; OriginationDate: 28/07/2025; Project Name: Design Projects; RevCreatedBy: J.S; RevCreationDate: 28/07/2025; Revision: M01; TAC NUMBER: C05+C05; WEIGHT: 18.92
PSet_Mass_Property - Area Measure: 1.6402905939715318; Mass Measure: 18.9159925204957062; Volume Measure: 0.0024251272462174

# IfcBuildingElementProxy: AECARCHITECTURALELEMENT (3)
In: default BuildingStorey
SOLIDWORKS Custom Properties - Finish: Unchecked
Name | DESCRIPTION | WEIGHT | Author = RevCreatedBy | GA | Number | OriginationDate = RevCreationDate | Project Name | Revision
SHEET^KI-0001-U01 | SHEET^KI-0001-U01 | 17.11
KI-0000-GS01 | KI-0000-GS01 | 0.90 | J.S | No | S-GS01 - 300 - 600 | 28/07/2025 | Design Projects | M01
KI-0000-GS01-1 | KI-0000-GS01 | 0.90 | J.S | No | S-GS01 - 300 - 600 | 28/07/2025 | Design Projects | M01

# IfcElementAssembly, KI-0001-U01
In: default BuildingStorey
SOLIDWORKS Custom Properties - Author: J.S; GA: No; Number: U - 01 - 300~600; OriginationDate: 28/07/2025; Project Name: Design Projects; RevCreatedBy: J.S; RevCreationDate: 28/07/2025; Revision: M01; TAC NUMBER: C05+C05; WEIGHT: 18.92
PSet_Mass_Property - Area Measure: 1.6402905939715318; Mass Measure: 18.9159925204957062; Volume Measure: 0.0024251272462174
