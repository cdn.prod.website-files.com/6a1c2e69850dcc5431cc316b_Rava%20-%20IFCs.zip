Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\SOLIDWORKS WORKING\00-KINLEY\SUBS\KI-0001-BU03.IFC
Time: 2026-05-01T10:22:41+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
SOLIDWORKS Custom Properties - Author: J.S; GA: No; Number: U - 01 - 300~600; OriginationDate: 28/07/2025; Project Name: Design Projects; RevCreatedBy: J.S; RevCreationDate: 28/07/2025; Revision: M01; TAC NUMBER: C05+C05; WEIGHT: 40.71
PSet_Mass_Property - Area Measure: 3.5331306368853186; Mass Measure: 40.7111221222750146; Volume Measure: 0.0347789746310609

# IfcBuilding, default Building
SOLIDWORKS Custom Properties - Author: J.S; GA: No; Number: U - 01 - 300~600; OriginationDate: 28/07/2025; Project Name: Design Projects; RevCreatedBy: J.S; RevCreationDate: 28/07/2025; Revision: M01; TAC NUMBER: C05+C05; WEIGHT: 40.71
PSet_Mass_Property - Area Measure: 3.5331306368853186; Mass Measure: 40.7111221222750146; Volume Measure: 0.0347789746310609

# IfcBuildingStorey, default BuildingStorey
In: default Building
SOLIDWORKS Custom Properties - Author: J.S; GA: No; Number: U - 01 - 300~600; OriginationDate: 28/07/2025; Project Name: Design Projects; RevCreatedBy: J.S; RevCreationDate: 28/07/2025; Revision: M01; TAC NUMBER: C05+C05; WEIGHT: 40.71
PSet_Mass_Property - Area Measure: 3.5331306368853186; Mass Measure: 40.7111221222750146; Volume Measure: 0.0347789746310609

# IfcBuildingElementProxy: AECARCHITECTURALELEMENT (5)
In: default BuildingStorey
SOLIDWORKS Custom Properties - Finish: Unchecked
Name | DESCRIPTION | WEIGHT
KI-0000-GS01 | KI-0000-GS01 | 0.90 | SOLIDWORKS Custom Properties - Author: J.S; GA: No; Number: S-GS01 - 300 - 600; OriginationDate: 28/07/2025; Project Name: Design Projects; RevCreatedBy: J.S; RevCreationDate: 28/07/2025; Revision: M01
SHEET^KI-0001-BU03 | SHEET^KI-0001-BU03 | 17.11
KI-0000-GS01-1 | KI-0000-GS01 | 0.90 | SOLIDWORKS Custom Properties - Author: J.S; GA: No; Number: S-GS01 - 300 - 600; OriginationDate: 28/07/2025; Project Name: Design Projects; RevCreatedBy: J.S; RevCreationDate: 28/07/2025; Revision: M01
Part2^KI-0001-BU03 | Part2^KI-0001-BU03 | 0.49 | SOLIDWORKS Custom Properties - Material: MILD STEEL
RAVA BENCH | RAVA BENCH | 21.31 | SOLIDWORKS Custom Properties - Material: IROKO

# IfcElementAssembly, KI-0001-BU03
In: default BuildingStorey
SOLIDWORKS Custom Properties - Author: J.S; GA: No; Number: U - 01 - 300~600; OriginationDate: 28/07/2025; Project Name: Design Projects; RevCreatedBy: J.S; RevCreationDate: 28/07/2025; Revision: M01; TAC NUMBER: C05+C05; WEIGHT: 40.71
PSet_Mass_Property - Area Measure: 3.5331306368853186; Mass Measure: 40.7111221222750146; Volume Measure: 0.0347789746310609
