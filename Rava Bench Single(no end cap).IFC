Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\SOLIDWORKS WORKING\00-KINLEY\SUBS\KI-0001-BU01.IFC
Time: 2026-05-01T10:24:55+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
SOLIDWORKS Custom Properties - Author: J.S; GA: No; Number: U - 01 - 300~600; OriginationDate: 28/07/2025; Project Name: Design Projects; RevCreatedBy: J.S; RevCreationDate: 28/07/2025; Revision: M01; TAC NUMBER: C05+C05; WEIGHT: 40.71
PSet_Mass_Property - Area Measure: 3.5331306368853177; Mass Measure: 40.7111221222750288; Volume Measure: 0.0347789746310609

# IfcBuilding, default Building
SOLIDWORKS Custom Properties - Author: J.S; GA: No; Number: U - 01 - 300~600; OriginationDate: 28/07/2025; Project Name: Design Projects; RevCreatedBy: J.S; RevCreationDate: 28/07/2025; Revision: M01; TAC NUMBER: C05+C05; WEIGHT: 40.71
PSet_Mass_Property - Area Measure: 3.5331306368853177; Mass Measure: 40.7111221222750288; Volume Measure: 0.0347789746310609

# IfcBuildingStorey, default BuildingStorey
In: default Building
SOLIDWORKS Custom Properties - Author: J.S; GA: No; Number: U - 01 - 300~600; OriginationDate: 28/07/2025; Project Name: Design Projects; RevCreatedBy: J.S; RevCreationDate: 28/07/2025; Revision: M01; TAC NUMBER: C05+C05; WEIGHT: 40.71
PSet_Mass_Property - Area Measure: 3.5331306368853177; Mass Measure: 40.7111221222750288; Volume Measure: 0.0347789746310609

# IfcBuildingElementProxy: AECARCHITECTURALELEMENT (5)
In: default BuildingStorey
SOLIDWORKS Custom Properties - Finish: Unchecked
Name | DESCRIPTION | Number | OriginationDate = RevCreationDate | Project Name | RevCreatedBy | Revision | WEIGHT
KI-0000-GS01 | KI-0000-GS01 | S-GS01 - 300 - 600 | 28/07/2025 | Design Projects | J.S | M01 | 0.90 | SOLIDWORKS Custom Properties - Author: J.S; GA: No
RAVA BENCH | RAVA BENCH |  |  |  |  |  | 21.31 | SOLIDWORKS Custom Properties - Material: IROKO
SHEET^KI-0001-BU01 | SHEET^KI-0001-BU01 |  |  |  |  |  | 17.11
KI-0000-GS01-1 | KI-0000-GS01 | S-GS01 - 300 - 600 | 28/07/2025 | Design Projects | J.S | M01 | 0.90 | SOLIDWORKS Custom Properties - Author: J.S; GA: No
Part2 | Part2 | Part2 | 25/02/2026 | Kinley Edging | J.S | P01 | 0.49 | SOLIDWORKS Custom Properties - Material: MILD STEEL; Project: 1567

# IfcElementAssembly, KI-0001-BU01
In: default BuildingStorey
SOLIDWORKS Custom Properties - Author: J.S; GA: No; Number: U - 01 - 300~600; OriginationDate: 28/07/2025; Project Name: Design Projects; RevCreatedBy: J.S; RevCreationDate: 28/07/2025; Revision: M01; TAC NUMBER: C05+C05; WEIGHT: 40.71
PSet_Mass_Property - Area Measure: 3.5331306368853177; Mass Measure: 40.7111221222750288; Volume Measure: 0.0347789746310609
